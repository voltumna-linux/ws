### DISABLED_FEATURES:remove:class-nativesdk = "PyQt_OpenGL"

BBCLASSEXTEND = "nativesdk"
