BBCLASSEXTEND = "nativesdk"

